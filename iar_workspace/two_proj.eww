<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Humiture_Ex\Humiture_Ex.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\point_to_point\IAR\RF-test.ewp</path>
  </project>
  <batchBuild/>
</workspace>


