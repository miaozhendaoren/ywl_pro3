# IAR project RF-test.ewp, settings and files
configuration RX (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM; RX; xTX
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../source/Components/utils; ../source/Components/common; ../source/Components/basicrf; ../source/Components/targets/interface; ../source/Components/assembly; ../source/Components/common/cc8051; ../source/Components/targets/srf05_soc; ../source/Components/radios/cc2530; ../source/apps/RF_text
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew.xcl
configuration TX (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM; xRX; TX
  group application
    ../source/apps/RF_text/: app_ex_main.c rf_test1.c
  group basicrf
    ../source/components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal
    ../source/components/radios/cc2530/: clock.c clock.h hal_mcu.c hal_rf.c hal_rf_security.c hal_rf_util.c hal_timer_32k.c
    ../source/components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_joystick.c hal_led.c
    ../source/components/targets/interface/: hal_assert.h hal_digio.h hal_int.h hal_led.h hal_mcu.h hal_rf.h hal_rf_security.h hal_rf_util.h hal_timer_32k.h hal_uart.h
    ../source/components/common/cc8051/: hal_cc8051.h
    ../source/components/common/: hal_defs.h hal_int.c hal_types.h
  group sht11
    ../source/components/sht11/: SHT11.c SHT11.h
  group utilities
    ../source/components/utils/: util.c util.h util_buffer.c util_buffer.h util_menu.h
